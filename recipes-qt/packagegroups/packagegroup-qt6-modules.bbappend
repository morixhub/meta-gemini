# Add dependencies
RDEPENDS:${PN}:append = " \
    qtmqtt \
    qtmultimedia \
    qtserialport \
    qtserialbus \
    qtwebengine \
    qtwebsockets \
    qtwebview"

