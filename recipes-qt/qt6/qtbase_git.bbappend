PACKAGECONFIG:append = " sql-sqlite "