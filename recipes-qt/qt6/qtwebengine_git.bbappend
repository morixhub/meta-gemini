DEPENDS:remove="gn-native"

DEPENDS += "qtgn-native"

