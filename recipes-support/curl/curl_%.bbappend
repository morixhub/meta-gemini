PACKAGECONFIG:append = " libssh2"