SUMMARY = "Aesys IMAGER image for UDisplay"

# Start from UDisplay image...
require aesys-udisplay-image.bb

# ...and make it an IMAGER image
require imager-image.inc
