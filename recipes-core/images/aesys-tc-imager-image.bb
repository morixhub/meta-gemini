SUMMARY = "Aesys IMAGER image for TC"

# Start from TC image...
require aesys-tc-image.bb

# ...and make it an IMAGER image
require imager-image.inc


