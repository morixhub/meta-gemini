PACKAGECONFIG:append = " tls"

#//!! Tentative
SRC_URI:remove = "file://0001-meson-Use-new-pkgconfig-for-aml1.patch"
SRC_URI:remove = "file://0001-Use-aml-v1.patch"
