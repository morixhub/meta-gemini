# Remove IMX-GPU-SDK
SOC_TOOLS_GPU:imxgpu:remove = "imx-gpu-sdk"

# Remove other test tools
SOC_TOOLS_DRM:imxdrm = ""
