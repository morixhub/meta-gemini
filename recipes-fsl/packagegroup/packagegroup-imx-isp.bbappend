# Remove ISP test packages
ISP_PKGS:mx8mp-nxp-bsp:remove = "isp-imx"