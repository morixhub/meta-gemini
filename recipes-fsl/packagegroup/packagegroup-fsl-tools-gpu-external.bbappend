# Remove various test tools/benchmarks
DRM_TOOLS:imxdrm = ""
OPENCL_TOOLS = ""
VULKAN_TOOLS:imxgpu3d = ""
GLMARK2:imxgpu3d = ""